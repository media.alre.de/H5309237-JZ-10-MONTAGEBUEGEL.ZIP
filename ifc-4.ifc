Properties of the parts of a building model (IFC4)

# File
Description: Montagebügel für JDL 109/-113 und JDW-3/-5/-10, mit 6 Schrauben, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H5309237, Montagebügel für JDL 109/-113 und JDW-3/-5/-10, mit 6 Schrauben
In: Raum
Description: Montagebügel für Differenzdruckschalter JDL 109/-113 und JDW-3/-5/-10, mit 6 Schrauben; Classification: EC010111 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H5309237; ModelLabel: JZ-10; GlobalTradeItemNumber: 4050528044686; ProductURL: https://alre.de/produkt_H5309237
Pset_Specification - NominalLength: 0.073 m; NominalWidth: 0.05 m; NominalDepth: 0.01 m; NetWeight: 0.036
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: Montageplatte; Zubehör: yes; ETIM-Klasse: EC010111; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H5309237.pdf
